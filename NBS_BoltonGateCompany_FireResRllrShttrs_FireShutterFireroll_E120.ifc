Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-04-28T09:39:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.30.41
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Apr 28 09:39:16 2022* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\{891071F1-5DA0-45EA-ACDA-EFA881CA311A}\ifc* Database version: 5507* Database creation date: Thu Apr 28 09:39:13 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Apr 28 09:39:13 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Apr 28 09:39:13 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDoor: FireShutterFireroll_E120, NBS_BoltonGateCompany_FireResRllrShttrs_FireShutterFireroll_E120:FireShutterFireroll_E120:306674
In: Level 0
Type - OperationType: ROLLINGUP; ConstructionType: STEEL; ParameterTakesPrecedence: no; Sizeable: no; Material: NBS_BoltonGateCompany_Galvanised, NBS_BoltonGateCompany_SteelLaths_76mm_Galvanised
Type - NBS_BoltonGateCompany_FireResRllrShttrs_FireShutterFireroll_E120:FireShutterFireroll_E120:306674 - PanelOperation: ROLLINGUP
Type - BOS_General - Author: NBS; BIMObjectName: NBS_BoltonGateCompany_FireResistingRollerShutters_FireShutterFireroll_E120; ManufacturerName: Bolton Gate Company; ManufacturerURL: www.boltongate.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/qd0o1niy; ProductInformation: n/a; Uniclass2015Title: Fire-resisting roller shutters; Uniclass2015Code: Pr_30_59_84_30; Uniclass2015Version: Products v1.22; Version: 1
Type - NBS_Data - ContainsRedListMaterials: No; CountryOfMaterialOrigin: United Kingdom; CountryOfProductManufacture: United Kingdom; EmbodiedCarbon: n/a; Recyclability: 95%; RecycledContent: 0; Standard: Internal / external fire rated roller shutter CE marked to BS EN 13241 and BS EN 16034; OpeningSizes: 7000mm wide x 7000mm high as standard, 12000mm wide - height dependent (please contact our sales team to discuss); Format: Internal/ external; Arrangement: Vertical; PerformanceFirePerformanceResistanceToFire: Integrity (E) 120; PerformanceFirePerformanceSmokeControl: n/a; Watertightness: n/a; ResistanceToWindLoad: Class 3; AcousticPerformance: n/a; ThermalResistance: n/a; AirPermeability: n/a; ApplicationConformity: n/a; IntruderResistanceRequirement: n/a; BulletResistance: n/a; ExplosionResistanceBlastDuration: n/a; ExplosionResistancePressureMode: n/a; ExplosionResistanceOverpressureMaximum: n/a; ExplosionResistanceReboundPressureMaximum: n/a; Accessibility: n/a; FrameAndGuidesMaterialPerimeterSealsOrInserts: n/a; FrameAndGuidesMaterialFinish: Galvanized ,Powder coated; FrameAndGuidesMaterialColour: Silver, RAL; FrameAndGuidesMaterialFilmThicknessMinimum: n/a; FrameAndGuidesMaterialInstallationFasteners: n/a; FrameAndGuidesMaterialFrameAccessories: n/a; ShutterCurtainLathMaterial: Galvanized steel, Stainless steel, 1.4301 (304) grade, Stainless steel, 1.4401 (316) grade; ShutterCurtainProfile: Curved; ShutterCurtainFinishAndColour: Galvanized, Powder coated, RAL, Stainless steel; Execution: Workmanship in joinery; OperatingForces: Electric operation as standard complete with manual override for use in the event of power failure; Mode: Activation via a signal for the fire alarm system to an auto reset solenoid; OperationControl: 230 V nominal, single-phase, 400 V nominal, three-phase; Accessories: Not required, Fire door control panel with integrated audio-visual warning, Heat/ smoke detectors; Weight: 50 kg/m²
Type - IFC - IfcExportAs: IfcDoor; IfcExportType: DOOR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_84_30:Fire-resisting roller shutters; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Galvanized, Powder coated; Grade: n/a; Manufacturer: sales@boltongate.co.uk; Material: Steel; ModelNumber: n/a; ModelReference: FireShutterFireroll_E120; Name: FireResistingRollerShutters_FireShutterFireroll_E120_BoltonGateCompany; NominalLength: 0 mm; ReplacementCost: n/a; Shape: Square, Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: One year; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OverallHeight: 2460 mm; OverallWidth: 3044 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
